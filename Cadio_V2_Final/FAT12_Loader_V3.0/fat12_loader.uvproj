# Keil uVision project fat12_loader.uvproj, settings and files
target Target_1 (MCS-51)
  device: AI8H8K64U Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: fat12_loader +hex
  c flags: Optimize=9
  c include: .\comm;.\fat12;.\hardware
  link misc: REMOVEUNUSED
  group main
    ./: main.c STARTUP.A51
  group comm
    ./comm/: _STC8X_.h TYPE.H
  group hardware
    ./hardware/: ADC.C BM8563.c EEPROM.c oled.c W25QXX.c
  group fs
    ./fat12/: FAT12.c
