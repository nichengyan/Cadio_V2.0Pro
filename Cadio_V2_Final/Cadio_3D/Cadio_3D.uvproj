# Keil uVision project Cadio_3D.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: Cadio_3D +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\comm;.\hardware;.\graphic
  group main
    ./: STARTUP.A51 main.c
  group hardware
    ./hardware/: ADC.C Key.c oled.c W25QXX.c
  group comm
    ./comm/: _STC8X_.h config.h TYPE.H
  group graphic
    ./graphic/: Graphic.c
