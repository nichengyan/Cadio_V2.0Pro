# Keil uVision project sd+kunbox.uvproj, settings and files
target Target 1 (MCS-51)
  device: AI8H8K64U Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: sd+kunbox +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\comm;.\fatfs;.\hardware
  group main
    ./: STARTUP.A51 main.c
  group comm
    ./comm/: _STC8X_.h TYPE.H
  group hardware
    ./hardware/: ADC.C Key.c oled.c SD.c
  group fatfs
    ./fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
