# Keil uVision project SD_Reader.uvproj, settings and files
target Target 1 (MCS-51)
  device: AI8H8K64U Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: SD_Reader +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  link misc: REMOVEUNUSED
  group main
    ./: STARTUP.A51
    ./src/: main.c memory.c scsi.c usb.c usb_desc.c usb_req_class.c usb_req_std.c usb_req_vendor.c util.c SD.c oled.c ADC.C
