# Keil uVision project jilehe.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: jilehe +hex
  c flags: Optimize=9
  c include: .\hardware;.\comm;.\fat12
  group main
    ./: STARTUP.A51 main.c
  group hardware
    ./hardware/: ADC.C Key.c oled.c W25QXX.c
  group fat12
    ./fat12/: FAT12_2.c
  group comm
    ./comm/: _STC8X_.h config.h TYPE.H
