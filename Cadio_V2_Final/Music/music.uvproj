# Keil uVision project music.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: music +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\comm;.\hardware
  group main
    ./: STARTUP.A51 main.c
  group hardware
    ./hardware/: ADC.C EEPROM.c oled.c W25QXX.c Key.c Buzzer.c
  group comm
    ./comm/: config.h TYPE.H _STC8X_.h
