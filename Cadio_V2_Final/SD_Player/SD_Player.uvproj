# Keil uVision project SD_Player.uvproj, settings and files
target Target 1 (MCS-51)
  device: AI8H8K64U Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: SD_Player +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\comm;.\fatfs;.\graphic;.\hardware
  group main
    ./: STARTUP.A51 main.c
    ../../../C51/LIB/: C51FPL.LIB
  group comm
    ./comm/: _STC8X_.h TYPE.H Volume.h
  group hardware
    ./hardware/: ADC.C Key.c oled.c SD.c
  group fatfs
    ./fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
  group graphic
    ./graphic/: Graphic.c
