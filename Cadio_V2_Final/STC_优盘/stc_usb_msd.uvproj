# Keil uVision project stc_usb_msd.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: stc_usb_msd +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./src/: main.c usb.c usb_desc.c usb_req_class.c usb_req_std.c usb_req_vendor.c util.c scsi.c memory.c oledfont.h oled.c _STC8X_.h ADC.C
    ./: 功能说明.txt
    ../../STC_科学计算器/: STARTUP.A51
