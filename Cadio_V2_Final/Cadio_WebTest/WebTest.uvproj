# Keil uVision project WebTest.uvproj, settings and files
target Target 1 (MCS-51)
  device: AI8H8K64U Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: WebTest +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\comm;.\gui;.\hardware;.\fatfs
  link misc: REMOVEUNUSED
  group main
    ./: STARTUP.A51 main.c
    ./comm/: TYPE.H
  group gui
    ./gui/: Gui.c
  group hardware
    ./hardware/: ADC.C Key.c oled.c UART.C SD.c
  group comm
    ./comm/: _STC8X_.h TYPE.H
  group fatfs
    ./fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
