# Keil uVision project Bad_apple.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: Bad_apple +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\comm;.\fat12;.\hardware
  link misc: REMOVEUNUSED
  group main
    ./: STARTUP.A51 main.c
  group hardware
    ./hardware/: ADC.C Key.c oled.c W25QXX.c
  group fat12
    ./fat12/: FAT12_2.c
  group comm
    ./comm/: config.h TYPE.H _STC8X_.h
