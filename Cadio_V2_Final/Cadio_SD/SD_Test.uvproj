# Keil uVision project SD_Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AI8H8K64U Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: SD_Test +hex
  c flags: Optimize=7
  c include: .\comm;.\hardware;.\fatfs;.\graphic
  group main
    ./: STARTUP.A51 main.c
  group comm
    ./comm/: _STC8X_.h TYPE.H
  group hardware
    ./hardware/: oled.c SD.c Key.c ADC.C
  group fatfs
    ./fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
  group graphic
    ./graphic/: Graphic.c
