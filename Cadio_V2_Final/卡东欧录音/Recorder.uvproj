# Keil uVision project Recorder.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: Recorder +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\comm;.\hardware;.\fat12;.\gui
  link misc: REMOVEUNUSED
  group main
    ./: STARTUP.A51 main.c
  group comm
    ./comm/: _STC8X_.h TYPE.H
  group hardware
    ./hardware/: ADC.C Key.c oled.c W25QXX.c
  group fat12
    ./fat12/: FAT12_2v1.c
