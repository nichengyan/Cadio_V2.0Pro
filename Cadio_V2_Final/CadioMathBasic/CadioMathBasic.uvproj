# Keil uVision project CadioMathBasic.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: CadioMathBasic +hex
  c flags: Optimize=9
  c include: .\calculator;.\comm;.\Expression;.\gui;.\hardware;.\Menu0;.\funcpic;.\BeginUI;.\settings
  link misc: REMOVEUNUSED
  group main
    ./: STARTUP.A51 main.c
  group hardware
    ./hardware/: ADC.C Key.c oled.c
  group comm
    ./comm/: _STC8X_.h TYPE.H
  group expression
    ./Expression/: Expression.c
  group gui
    ./gui/: Gui.c
  group Begin
    ./BeginUI/: Begin.c
  group Calculator
    ./calculator/: cal.c
  group Function
    ./funcpic/: fun.c
  group Settings
    ./settings/: set.c
