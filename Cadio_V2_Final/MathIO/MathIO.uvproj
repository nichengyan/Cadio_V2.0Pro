# Keil uVision project MathIO.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: MathIO +hex
  c flags: Optimize=9
  c include: .\comm;.\editor;.\Expression;.\fat12;.\gui;.\hardware;.\tick
  link misc: REMOVEUNUSED
  group main
    ./: STARTUP.A51 main.c
  group comm
    ./comm/: _STC8X_.h TYPE.H
  group hardware
    ./hardware/: ADC.C Key.c oled.c W25QXX.c
  group expression
    ./Expression/: Expression.c
  group fat12
    ./fat12/: FAT12_2v1.c
  group gui
    ./gui/: Gui.c
  group tick
    ./tick/: tick.c
  group editor
    ./editor/: editor.c
