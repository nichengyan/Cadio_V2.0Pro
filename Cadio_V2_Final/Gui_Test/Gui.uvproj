# Keil uVision project Gui.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: Gui +hex
  c include: .\comm;.\hardware;.\fat12;.\gui;.\Expression;.\graphic
  group main
    ./: main.c STARTUP.A51
  group comm
    ./comm/: TYPE.H _STC8X_.h
  group hardware
    ./hardware/: ADC.C Key.c oled.c
  group Gui_Core
    ./gui/: Animation.c Group.c Gui.c Widget.c Page.c
  group Widget
    ./gui/: Widget_Bmp.c
  group Graphic
    ./graphic/: Graphic.c
  group User
    ./gui/: Page0.c
