# Keil uVision project msc_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AI8H8K64U Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: msc_test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\hardware;.\usb_msc
  link misc: REMOVEUNUSED
  group main
    ./: STARTUP.A51 main.c
  group hardware
    ./hardware/: ADC.C oled.c SD.c
  group usb_msc
    ./usb_msc/: memory.c scsi.c usb.c usb_desc.c usb_req_class.c usb_req_std.c usb_req_vendor.c util.c
