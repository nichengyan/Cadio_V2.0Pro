# Keil uVision project FAT12_Loader.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: FAT12_Loader +hex
  c flags: Optimize=9
  c include: .\comm;.\fat12;.\hardware
  link misc: REMOVEUNUSED
  group main
    ./: STARTUP.A51 main.c
  group hardware
    ./hardware/: ADC.C EEPROM.c oled.c W25QXX.c BM8563.c
  group comm
    ./comm/: config.h TYPE.H _STC8X_.h
  group fat12
    ./fat12/: FAT12.c
