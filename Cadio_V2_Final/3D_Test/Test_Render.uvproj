# Keil uVision project Test_Render.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: Test_Render
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51
