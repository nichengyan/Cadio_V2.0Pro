# Keil uVision project yzxg.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: yzxg +hex
  c flags: Optimize=8 SizeSpeed=1
  group main.c
    ./: STARTUP.A51 main.c
  group comm
    ./comm/: _STC8H_.h config.h TYPE.H
  group hardware
    ./hardware/: ADC.C Buzzer.c Key.c oled.c W25QXX.c
  group Songs
    ./songs/: castle_in_the_sky.h jingle_bell.h 粉红色的回忆.h 花桥流水.h 老六进行曲.h 没有共产党就没有新中国.h 膜你抄_第一段.h 杨中校歌.h 幼女幻奏.h 造反有理.h 郑州一中校歌.h
